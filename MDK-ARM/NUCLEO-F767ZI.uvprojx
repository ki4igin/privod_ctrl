# Keil uVision project NUCLEO-F767ZI.uvprojx, settings and files
target NUCLEO-F767ZI (6190000::V6.19::ARMCLANG)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.1
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: NUCLEO-F767ZI +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F767xx
  c misc: -ffp-mode=fast
  c include: ../code/Inc;../code/Middlewares/Third_Party/LwIP/src/include;../code/Middlewares/Third_Party/LwIP/system;../code/Drivers/STM32F7xx_HAL_Driver/Inc;../code/Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../code/Drivers/BSP/Components/lan8742;../code/Middlewares/Third_Party/LwIP/src/include/netif/ppp;../code/Drivers/CMSIS/Device/ST/STM32F7xx/Include;../code/Middlewares/Third_Party/LwIP/src/include/lwip;../code/Middlewares/Third_Party/LwIP/src/include/lwip/apps;../code/Middlewares/Third_Party/LwIP/src/include/lwip/priv;../code/Middlewares/Third_Party/LwIP/src/include/lwip/prot;../code/Middlewares/Third_Party/LwIP/src/include/netif;../code/Middlewares/Third_Party/LwIP/src/include/compat/posix;../code/Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa;../code/Middlewares/Third_Party/LwIP/src/include/compat/posix/net;../code/Middlewares/Third_Party/LwIP/src/include/compat/posix/sys;../code/Middlewares/Third_Party/LwIP/src/include/compat/stdc;../code/Middlewares/Third_Party/LwIP/system/arch;../code/Drivers/CMSIS/Include;../code/Middlewares\motor;..\code\Src
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Application/User
    ../code/Src/: udp_server.c array.c main.c gpio.c dma.c lwip.c ethernetif.c spi.c tim.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c opamp.c iir_filter.c perv.c ab_filter.c second.c debug.c rcc.c mov_mean.c calib.c
  group Drivers/BSP/Components
    ../code/Drivers/BSP/Components/lan8742/: lan8742.c
  group Drivers/STM32F7xx_HAL_Driver
    ../code/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_ll_gpio.c stm32f7xx_ll_rcc.c stm32f7xx_ll_utils.c stm32f7xx_ll_exti.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_eth.c stm32f7xx_ll_dma.c stm32f7xx_ll_spi.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_ll_tim.c stm32f7xx_ll_usart.c
  group Drivers/CMSIS
    ../code/Src/: system_stm32f7xx.c
  group Middlewares/LwIP
    ../code/Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../code/Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
    ../code/Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../code/Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../code/Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../code/Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../code/Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
  group Middlewares/motor
    ../code/Middlewares/motor/: crc16.c modbus.c motor.c servo.c uart.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.4, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
